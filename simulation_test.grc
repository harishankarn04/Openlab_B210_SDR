options:
  parameters:
    description: Smart GFSK Loopback with Custom Media Source/Sink
    generate_options: no_gui
    hier_block_src_path: '.: '
    id: simulation_test
    output_language: python
    title: Smart GFSK Test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.1'
    seed: '0'
    taps: '1.0'
  states: {}
- name: custom_gfsk_custom_file_sink_0
  id: custom_gfsk_custom_file_sink
  parameters:
    output_file: /Users/harishankar/Documents/gitClone/SDR_USPR_B210/images/shadab_output.jpg
  states: {}
- name: custom_gfsk_custom_file_source_0
  id: custom_gfsk_custom_file_source
  parameters:
    filepath: /Users/harishankar/Documents/gitClone/SDR_USPR_B210/images/shadab.jpeg
    image_quality: '30'
    video_bitrate: '200'
    video_fps: '24'
    video_resolution: '480'
  states: {}
- name: custom_gfsk_rx_0
  id: custom_gfsk_rx
  parameters:
    enable_fec: 'True'
    sample_rate: samp_rate
    samples_per_symbol: '2'
    sync_threshold: '4'
  states: {}
- name: custom_gfsk_tx_0
  id: custom_gfsk_tx
  parameters:
    enable_fec: 'True'
    samples_per_symbol: '2'
    tx_amplitude: '0.7'
  states: {}

connections:
- [channels_channel_model_0, '0', custom_gfsk_rx_0, '0']
- [custom_gfsk_custom_file_source_0, '0', custom_gfsk_tx_0, '0']
- [custom_gfsk_rx_0, '0', custom_gfsk_custom_file_sink_0, '0']
- [custom_gfsk_tx_0, '0', channels_channel_model_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
