options:
  parameters:
    generate_options: qt_gui
    id: hardware_test
    output_language: python
    title: Hardware Test Robust Custom GFSK
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '915000000'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '50'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '50'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.1'
    seed: '0'
    taps: '1.0'
  states: {state: disabled}
- name: custom_gfsk_custom_file_sink_0
  id: custom_gfsk_custom_file_sink
  parameters:
    output_file: /Users/harishankar/Downloads/scratch/hardware_recovered
  states: {}
- name: custom_gfsk_custom_file_source_0
  id: custom_gfsk_custom_file_source
  parameters:
    filepath: /Users/harishankar/Downloads/scratch/test_pattern.jpg
    image_quality: '30'
    video_bitrate: '200'
    video_fps: '24'
    video_resolution: '480'
  states: {}
- name: custom_gfsk_rx_0
  id: custom_gfsk_rx
  parameters:
    enable_fec: 'True'
    sample_rate: samp_rate
    samples_per_symbol: '4'
    sync_threshold: '4'
  states: {}
- name: custom_gfsk_tx_0
  id: custom_gfsk_tx
  parameters:
    enable_fec: 'True'
    samples_per_symbol: '4'
    tx_amplitude: '0.7'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bandwidth0: '0'
    center_freq0: freq
    clock_rate: '0.0'
    dev_args: '""'
    gain0: tx_gain
    samp_rate: samp_rate
    show_ports: 'False'
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bandwidth0: '0'
    center_freq0: freq
    clock_rate: '0.0'
    dev_args: '""'
    gain0: rx_gain
    samp_rate: samp_rate
    show_ports: 'False'
    sync: sync
    type: fc32
  states: {}

connections:
- [custom_gfsk_custom_file_source_0, '0', custom_gfsk_tx_0, '0']
- [custom_gfsk_rx_0, '0', custom_gfsk_custom_file_sink_0, '0']
- [custom_gfsk_tx_0, '0', uhd_usrp_sink_0, '0']
- [uhd_usrp_source_0, '0', custom_gfsk_rx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
